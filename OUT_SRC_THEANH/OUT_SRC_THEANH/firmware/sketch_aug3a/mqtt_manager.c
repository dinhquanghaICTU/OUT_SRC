#include "mqtt_manager.h"
#include "config.h"
#include "wifiAP.h"
#include "ring.h"

#include <esp_random.h>
#include <esp_timer.h>
#include <inttypes.h>
#include <mqtt_client.h>
#include <stdio.h>
#include <string.h>

static esp_mqtt_client_handle_t mqtt_client = NULL;
static bool mqtt_started = false;
static bool mqtt_connected = false;
static uint32_t mqtt_boot_id = 0;
static uint32_t telemetry_sequence = 0;

static void
mqtt_event_handler(void *handler_args, esp_event_base_t base, int32_t event_id, void *event_data)
{
    (void)handler_args;
    (void)base;
    esp_mqtt_event_handle_t event = (esp_mqtt_event_handle_t)event_data;

    switch ((esp_mqtt_event_id_t)event_id)
    {
    case MQTT_EVENT_CONNECTED:
        mqtt_connected = true;

        int message_id =
            esp_mqtt_client_subscribe(mqtt_client, MQTT_SUB_CONFIG_DESIRED_TOPIC, 1);
        int cmd_message_id =
            esp_mqtt_client_subscribe(mqtt_client, MQTT_SUB_COMMAND_TOPIC, 1);

        printf("[MQTT] Da ket noi broker
");
        printf("[MQTT] Subscribe topic=%s, msg_id=%d
",
               MQTT_SUB_CONFIG_DESIRED_TOPIC,
               message_id);
        printf("[MQTT] Subscribe topic=%s, msg_id=%d
",
               MQTT_SUB_COMMAND_TOPIC,
               cmd_message_id);
        break;

    case MQTT_EVENT_DISCONNECTED:
        mqtt_connected = false;
        printf("[MQTT] Mat ket noi broker
");
        break;

    case MQTT_EVENT_ERROR:
        mqtt_connected = false;
        printf("[MQTT] Loi ket noi broker
");
        break;
    case MQTT_EVENT_DATA:
    {
        printf("[MQTT] Topic: %.*s
", event->topic_len, event->topic);
        printf("[MQTT] Payload: %.*s
", event->data_len, event->data);

        // Kiem tra neu la topic lenh dieu khien tu Server
        if (event->topic_len == (int)strlen(MQTT_SUB_COMMAND_TOPIC) &&
            memcmp(event->topic, MQTT_SUB_COMMAND_TOPIC, event->topic_len) == 0)
        {
            char payload[256];
            int len = event->data_len < 255 ? event->data_len : 255;
            memcpy(payload, event->data, len);
            payload[len] = '';

            // Kiem tra trang thai bat/tat coi tu app
            if (strstr(payload, ""state":true") != NULL ||
                strstr(payload, ""state": true") != NULL ||
                strstr(payload, ""ring":true") != NULL ||
                strstr(payload, ""ring": true") != NULL ||
                strstr(payload, ""buzzer":true") != NULL ||
                strstr(payload, ""buzzer": true") != NULL)
            {
                printf("[BUZZER] Bat coi canh bao tu Server (GPIO %d)
", RING_PIN);
                turn_on_ring();
            }
            else if (strstr(payload, ""state":false") != NULL ||
                     strstr(payload, ""state": false") != NULL ||
                     strstr(payload, ""ring":false") != NULL ||
                     strstr(payload, ""ring": false") != NULL ||
                     strstr(payload, ""buzzer":false") != NULL ||
                     strstr(payload, ""buzzer": false") != NULL)
            {
                printf("[BUZZER] Tat coi canh bao tu Server (GPIO %d)
", RING_PIN);
                turn_off_ring();
            }
            break;
        }

        break;
    }
    default:
        break;
    }
}

void mqtt_manager_start(void)
{
    if (mqtt_started)
        return;

    if (mqtt_boot_id == 0)
        mqtt_boot_id = esp_random();

    const char *broker_uri = wifi_manager_get_mqtt_broker_uri();
    const esp_mqtt_client_config_t config = {.broker.address.uri = broker_uri,
                                             .session.keepalive = 30,
                                             .network.reconnect_timeout_ms = 5000,
                                             .buffer.size = 1024,
                                             .buffer.out_size = 1024};

    mqtt_client = esp_mqtt_client_init(&config);
    if (mqtt_client == NULL)
    {
        printf("[MQTT] Khoi tao client that bai
");
        return;
    }

    esp_mqtt_client_register_event(mqtt_client, MQTT_EVENT_ANY, mqtt_event_handler, NULL);

    if (esp_mqtt_client_start(mqtt_client) != ESP_OK)
    {
        printf("[MQTT] Start client that bai
");
        esp_mqtt_client_destroy(mqtt_client);
        mqtt_client = NULL;
        return;
    }

    mqtt_started = true;
    printf("[MQTT] Dang ket noi: %s
", broker_uri);
}

void mqtt_manager_stop(void)
{
    if (!mqtt_started || mqtt_client == NULL)
        return;

    esp_mqtt_client_stop(mqtt_client);
    esp_mqtt_client_destroy(mqtt_client);
    mqtt_client = NULL;
    mqtt_started = false;
    mqtt_connected = false;
    printf("[MQTT] Da dung client
");
}

bool mqtt_manager_is_connected(void)
{
    return mqtt_connected;
}

bool mqtt_manager_publish_sensor(float uv_voltage, float uv_index, float pressure_hpa)
{
    char payload[384];
    int length;
    const uint32_t sequence = ++telemetry_sequence;
    const uint64_t uptime_ms = (uint64_t)(esp_timer_get_time() / 1000);

    if (!mqtt_connected || mqtt_client == NULL)
        return false;

    length = snprintf(payload,
                      sizeof(payload),
                      "{"schema_version":1,"
                      ""device_id":"%s","
                      ""message_id":"%s-%08" PRIx32 "-%" PRIu32 "","
                      ""sequence":%" PRIu32 ","
                      ""uptime_ms":%" PRIu64 ","
                      ""firmware_version":"%s","
                      ""metrics":{"
                      ""uv_voltage":%.3f,"
                      ""uv_index":%.2f,"
                      ""pressure_hpa":%.2f,"
                      ""relay":%s,"
                      ""ring":%s}}",
                      PRODUCT_ID,
                      PRODUCT_ID,
                      mqtt_boot_id,
                      sequence,
                      sequence,
                      uptime_ms,
                      FIRMWARE_VERSION,
                      uv_voltage,
                      uv_index,
                      pressure_hpa,
                      ring_get_state() ? "true" : "false",
                      ring_get_state() ? "true" : "false");

    if (length <= 0 || length >= (int)sizeof(payload))
        return false;

    const int message_id =
        esp_mqtt_client_publish(mqtt_client, MQTT_PUB_TELEMETRY_TOPIC, payload, length, 1, 0);

    if (message_id < 0)
        return false;

    printf("[MQTT] Publish topic=%s, msg_id=%d
", MQTT_PUB_TELEMETRY_TOPIC, message_id);
    printf("[MQTT] Payload: %s
", payload);
    return true;
}
